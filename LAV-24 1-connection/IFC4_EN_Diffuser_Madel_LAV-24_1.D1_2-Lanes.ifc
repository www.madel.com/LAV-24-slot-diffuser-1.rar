Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: 0001
Time: 2023-02-21T11:52:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.2.1.0 - Alternate UI 21.2.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 11:52:30 2023 * Host: MSI * Database: C:\Users\info\AppData\Local\Temp\8755c7c7-9a8b-42d3-bcde-f965885910e8\c3c45371-2e94-4714-b6af-b8f392c8cd1a\ifc * Database version: 5507 * Database creation date: Tue Feb 21 11:52:30 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 11:52:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 11:52:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcAirTerminal: 2021_EN_Difusor_Madel_LAV-24_(1.D1):Difusor LAV-24 - 2 Lanes, 2021_EN_Difusor_Madel_LAV-24_(1.D1):Difusor LAV-24 - 2 Lanes:347748
In: Level 1
Type - PredefinedType: DIFFUSER; Material: Metal, Metal, Anodized White
Type - Analysis Results - Sound Curve: 0
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Double Lanes: yes; Single Lane: no
Type - Data - Air Diffusion Performance Index: 0; Air Flow Rate: 0; Air Flow rate Versus Flow Control Element: 0; Air flow Type: SUPPLYAIR; Core Set Horizontal: 0 deg; Core Set Vertical: 0 deg; Discharge Direction: ADJUSTABLE; Face Type: Singledeflection / doubledeflection; Finish Color: Blanco; Finish Type: Painted; Flow Pattern: LINEARSINGLE; Has Integral Control: no; Has Sound Attenuator: no; Has Thermal Insulation: no; Is External: no; Location: CEILINGINTERIOR; Neck Area: 0.0307907 m2; Number Of Slots: 1; Shape: Slot; Slot Width: 24 mm; Temperature Range: -10 // +20; Throw Length: 0 mm
Type - Dimensions - D1: 198 mm; DP: 38.3 mm; E: 111 mm; H: 256 mm; Height: 256 mm; N: 107.5 mm; R1: 99 mm; Weight: 0 kg; Width: 107.5 mm
Type - Electrical - Has Protective Earth: yes; Nominal Frequency: 0 Hz; Number of Poles: 1; Power Factor: 0; RatedCurrent: 0 A; Rated Voltage: 0 V
Type - General - Is Extended Warranty: yes; Maintenance Cost: 0
Type - Graphics - Offset: 0 mm
Type - Green Building Properties - Atmospheric Acidification Per Unit: 0; Climate Change Per Unit: 0; Energy Spent: 0; Eutrophication Per Unit: 0; Hazardous Waste Per Unit: 0; Inert Waste Per Unit: 0; NonHazardous Waste Per Unit: 0; Non Renewable Energy Consumption Per Unit: 0; Photochemical Ozone Formation Per Unit: 0; Radioactive Waste Per Unit: 0; Renewable Energy Consumption Per Unit: 0; Resource Depletion Per Unit: 0; Stratospheric Ozone Layer Destruction Per Unit: 0; Total Primary Energy Consumption Per Unit: 0; Water Consumption Per Unit: 0
Type - Identity Data - Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: www.bimetica.com; BIM Eelement Expiry Date: 15.02.2024; BIM Element Issue Date: 15.02.2023; BIM Profile URL: https://bimetica.com/en/bim-object-diffuser-madel-lav-24-1-inlet-16101.html; BIM technical support: https://bimsupport.info/en/fabricantes/madel-air-technical-diffusion-s-a/; CE Mark: yes; Contact Email: info@madel.com; Description: Diffuser with 24mm slot opening; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2021) Creation of Element.; License Number: XXX-XXXX7125; Manufacturer: MADEL AIR TECHNICAL DIFUSION, S.A; Model: LAV-24, 2 Lanes; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Owner: MADEL AIR TECHNICAL DIFUSION, S.A; Sales Representative Contact: info@madel.com; Technical Support Contact: info@madel.com; Telephone Contact: +34 938 898 091; Type Name: Difusor LAV-24 - 2 Lanes; URL: www.madel.com; Version: RVT2021
Type - Materials and Finishes - Diffuser Grille Material: Metal, Anodized White; Finish: Painted; Material: Metal
Type - Mechanical - Flow - Connector Diameter: 200 mm
Type - Other - Category: Air Terminals; Clear Area to Access: 0 mm; Family Name: 2021_EN_Difusor_Madel_LAV-24_(1.D1)
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Construction - Individual: yes; Interior: no; Left End Angle: no; Right End Angle: no
Data - Effective Area: 0.0264 m2; Slot Length: 1100 mm
Dimensions - Area: 0.553028 m2; D: 0 mm; I: 0 mm; L: 1200 mm; Length: 1100 mm; L Max: 1600 mm; L Min: 300 mm; Lr: 1200 mm; L Real: 1100 mm; M: 1134 mm; Size: 200 mmø; Volume: 0.0303706 m3
Graphics - DV: yes; IV: yes
Identity Data - Code: LAV-24-AR; Mark: 1; Reference: LAV-24-AR
Mechanical - System Classification: Supply Air
Mechanical - Flow - Flow: 0 m3/s
Other - Family: 2021_EN_Difusor_Madel_LAV-24_(1.D1): Difusor LAV-24 - 2 Lanes; Family and Type: 2021_EN_Difusor_Madel_LAV-24_(1.D1): Difusor LAV-24 - 2 Lanes; Type: 2021_EN_Difusor_Madel_LAV-24_(1.D1): Difusor LAV-24 - 2 Lanes; Type Id: 2021_EN_Difusor_Madel_LAV-24_(1.D1): Difusor LAV-24 - 2 Lanes
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_347748
Description: Flow; FlowDirection: SOURCEANDSINK
